options:
  parameters:
    author: David Johnson, G4DPZ
    category: '[AMSAT-UK]'
    comment: |-
      APRS Beacon Transmitter for Ettus B200 mini
      Generates Bell 202 AFSK from a pre-computed audio file,
      FM-modulates, and transmits via UHD sink.
      Use aprs_beacon.py --wav-out to generate the audio file.
    copyright: 2026 AMSAT-UK
    description: APRS position beacon transmitter using Bell 202 AFSK over FM
    generate_options: no_gui
    id: aprs_beacon_tx
    output_language: python
    run_options: run
    title: APRS Beacon TX (B200 mini)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: SDR sample rate (must be >= 480 kHz for B200 mini)
    value: '480000'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    comment: Audio sample rate (48 kHz = 40 samples/bit at 1200 baud)
    value: '48000'
  states: {}
- name: centre_freq
  id: variable
  parameters:
    comment: TX frequency in Hz (144.850 MHz to avoid UK APRS gateway)
    value: 144.85e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    comment: B200 mini TX gain (0-89)
    value: '89'
  states: {}
- name: fm_deviation
  id: variable
  parameters:
    comment: FM deviation in Hz (3000 Hz for 1200 baud packet)
    value: '3000'
  states: {}
- name: fm_sensitivity
  id: variable
  parameters:
    comment: 2*pi*deviation/audio_rate
    value: 2*3.14159265*fm_deviation/audio_rate
  states: {}
- name: wav_source
  id: blocks_wavfile_source
  parameters:
    file: aprs_beacon.wav
    repeat: 'True'
    comment: AFSK audio generated by aprs_beacon.py --wav-out
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    type: float
    samples_per_second: audio_rate
    comment: Not used when UHD sink is present — UHD controls timing
  states: {state: disabled}
- name: fm_mod
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: fm_sensitivity
    comment: Direct FM modulation — no pre-emphasis (data, not voice)
  states: {}
- name: resampler
  id: rational_resampler_xxx
  parameters:
    type: ccc
    interp: int(samp_rate/audio_rate)
    decim: '1'
    comment: Upsample 48 kHz -> 480 kHz (10:1)
  states: {}
- name: uhd_sink
  id: uhd_usrp_sink
  parameters:
    dev_args: '""'
    samp_rate: samp_rate
    center_freq0: centre_freq
    gain0: tx_gain
    ant0: TX/RX
    comment: Ettus B200 mini UHD sink
  states: {}

connections:
- [wav_source, '0', fm_mod, '0']
- [fm_mod, '0', resampler, '0']
- [resampler, '0', uhd_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.0.0
